<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\HelloWorld\HelloWorld.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\LED_Ex\LED_Practice.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Morse_Code_Assignement.ewp</path>
    </project>
    <batchBuild />
</workspace>
