<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\HW6_Proj_Q2_Ayichew.ewp</path>
    </project>
    <batchBuild />
</workspace>
