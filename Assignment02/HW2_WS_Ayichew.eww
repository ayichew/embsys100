<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\HW2_Proj_Ayichew.ewp</path>
    </project>
    <batchBuild />
</workspace>
